File: caravan/fridge.kicad_sch (KiCad schematic)
At the start: 16 parts

Commit message: Updated caravan schematic
Connections:
- new net: U?. (T), U?. (T)
